options:
  parameters:
    generate_options: qt_gui
    id: fileSource
    output_language: python
    title: Reading Binary Files
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100*10**3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Gilon Kraft\Desktop\.git\EEGR4613\Lab2\DSPBlocksbinary_file_100000Hz_1775953665.complex_float
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
